# Keil uVision project PX9.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PX9 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 iic.c iic.h key.c key.h led.c led.h main.c main.h smg.c smg.h sys.c sys.h ds1302.c ds1302.h onewire.c onewire.h
